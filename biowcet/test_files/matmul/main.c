#define SIZE 10
#ifdef CRON
#include "cron.h"
#endif

#define N 10

int mat1[N][N] = {
    {1, 2, 3, 4, 5, 6, 7, 8, 9, 10},
    {11, 12, 13, 14, 15, 16, 17, 18, 19, 20},
    {21, 22, 23, 24, 25, 26, 27, 28, 29, 30},
    {31, 32, 33, 34, 35, 36, 37, 38, 39, 40},
    {41, 42, 43, 44, 45, 46, 47, 48, 49, 50},
    {51, 52, 53, 54, 55, 56, 57, 58, 59, 60},
    {61, 62, 63, 64, 65, 66, 67, 68, 69, 70},
    {71, 72, 73, 74, 75, 76, 77, 78, 79, 80},
    {81, 82, 83, 84, 85, 86, 87, 88, 89, 90},
    {91, 92, 93, 94, 95, 96, 97, 98, 99, 100}
};

int mat2[N][N] = {
    {10, 20, 30, 40, 50, 60, 70, 80, 90, 100},
    {9, 18, 27, 36, 45, 54, 63, 72, 81, 90},
    {8, 16, 24, 32, 40, 48, 56, 64, 72, 80},
    {7, 14, 21, 28, 35, 42, 49, 56, 63, 70},
    {6, 12, 18, 24, 30, 36, 42, 48, 54, 60},
    {5, 10, 15, 20, 25, 30, 35, 40, 45, 50},
    {4, 8, 12, 16, 20, 24, 28, 32, 36, 40},
    {3, 6, 9, 12, 15, 18, 21, 24, 27, 30},
    {2, 4, 6, 8, 10, 12, 14, 16, 18, 20},
    {1, 2, 3, 4, 5, 6, 7, 8, 9, 10}
};

int main() {
    #ifdef CRON
        setupCronometer();
        uint32_t start = startCronometer();
    #endif

    int i, j, k; 

    int result[N][N];

    for (i = 0; i < N; i++) {
        for (j = 0; j < N; j++) {
            result[i][j] = 0;
            for (k = 0; k < N; k++) {
                result[i][j] += mat1[i][k] * mat2[k][j];
            }
        }
    }

    #ifdef CRON
        uint32_t cycles = stopCronometer(start);
    #endif
    return 0;
}

